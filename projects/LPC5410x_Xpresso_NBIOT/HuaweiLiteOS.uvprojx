# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54102J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: IRAM(0x02000000,0x00010000) IRAM2(0x02010000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LOS_LPC5410X, CPU_LPC54102J512UK49_cm4, DEBUG
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\cpu\arm\cortex-m4;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\link\keil;..\..\example\include;..\..\platform\LPC5410x_Xpresso;..\..\platform\LPC5410x_Xpresso\chip_driver;..\..\platform\LPC5410x_Xpresso\board_driver;..\..\peripheral;..\..\user\app_lpc5410x_nboit
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
  scatter file: ..\..\platform\LPC5410x_Xpresso\LPC5410x-LiteOS.sct
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/cm4
    ../../kernel/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group startup
    ../../platform/LPC5410x_Xpresso/: los_startup_keil.s
  group user
    ../../user/app_lpc5410x_nboit/: main_lpc5410x_nbiot.c los_dev_lpc_uart.c ocean_nb_sample.c
  group platform/LPC5410x_chip_driver
    ../../platform/LPC5410x_Xpresso/chip_driver/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_flashiap.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_inputmux.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rit.c fsl_rtc.c fsl_sctimer.c fsl_spi.c fsl_spi_dma.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c system_LPC54102_cm4.c keil_lib_power.lib fsl_debug_console.c fsl_shell.c
  group platform/LPC5410x_board_driver
    ../../platform/LPC5410x_Xpresso/board_driver/: board.c clock_config.c pin_mux.c lpcxpresso_5410x_key.c lpcxpresso_5410x_led.c lpcxpresso_5410x_rtc.c
  group platform/LPC54102J512
    ../../platform/LPC5410x_Xpresso/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group peripheral/neulbc95
    ../../peripheral/: neul_bc95.c
